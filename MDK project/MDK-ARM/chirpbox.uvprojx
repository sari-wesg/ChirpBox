# Keil uVision project chirpbox.uvprojx, settings and files
target chirpbox (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: chirpbox +hex
  AfterMake: D:\ProgramFiles(x86)\Keil_v5\ARM\gcc\bin\arm-none-eabi-objcopy.exe  -O binary .\chirpbox\chirpbox.elf .\chirpbox\bin\chirpbox.bin
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/: startup_stm32l476xx.s
  group Application/User
    ../tutorial/L476RG/: main.c
    ../Drivers/gcc/: syscalls.c
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/: system_stm32l4xx.c
  group Mixer Files
    ../src/mixer/L476RG_SX1276/: memxor.c mixer_internal.c mixer_transport.c
    ../src/mixer/: mixer.c mixer_history.c mixer_processing.c mixer_rand.c mixer_request.c
    ../Src/mixer/: mixer_data.c
    ../Src/gpi/: gpi.c
  group Chirpbox Functions
    ../Src/tools/Src/: ll_flash.c flash_if.c menu.c toggle.c trace_flash.c chirpbox_flash.c chirpbox_ds3231.c chirpbox_lzss.c chirpbox_md5.c
  group Chirpbox
    ../Src/chirpbox/: chirp_irqhandler.c chirp_topo.c chirp_gps.c chirp_stats.c chirp_lbt.c chirp_rtc.c
software components: CMSIS:CORE 4.3.0
